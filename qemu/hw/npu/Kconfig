## qemu/hw/npu/Kconfig
```kconfig
config NPU_PCI
    bool
    default y if PCI_DEVICES || PCIE_DEVICES
    depends on PCI && MSI_NONBROKEN
```
